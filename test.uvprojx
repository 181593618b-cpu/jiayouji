# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\BSP;.\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Hardware;.\Hardware;.\FreeRtos\inc;.\FreeRtos;.\FreeRtos\port\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./APP/: main.c
  group BSP
    ./BSP/: gd32f30x_it.c systick.c
  group FMW_CODE
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group FMW_PERI
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Hardware
    ./Hardware/: Delay.c Delay.h Flowmeter.c Flowmeter.h Key.c Key.h OLED.c OLED.h OLED_Font.h TIM6.c TIM6.h Buzzer.h Buzzer.c Keyboard.c Keyboard.h Screen.c Screen.h flash_store.h flash_store.c
  group FreeRtos/Src
    ./FreeRtos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRtos/Port
    ./FreeRtos/port/MemMang/: heap_4.c
    ./FreeRtos/port/RVDS/ARM_CM4F/: port.c
